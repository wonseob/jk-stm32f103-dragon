# IAR project SysTick.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STM3210E_EVAL; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210E-EVAL_SysTick.bin
  ILINK.IlinkOutputFile: SysTick.out
  ILINK.IlinkIcfFile: stm32f10x_flash_offset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STM3210B_EVAL; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  OBJCOPY.OOCOutputFile: STM3210B-EVAL_SysTick.bin
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STM3210C_EVAL; STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  OBJCOPY.OOCOutputFile: STM3210C-EVAL_SysTick.bin
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  ICCARM.CCDefines: USE_STM3210E_EVAL; STM32F10X_XL; USE_STDPERIPH_DRIVER
  OBJCOPY.OOCOutputFile: STM3210E_XL_SysTick.bin
configuration STM32L152_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  ICCARM.CCDefines: USE_STM32L152_EVAL; STM32L1XX_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32l1xx_flash_offset.icf
configuration STM32L152D_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  ICCARM.CCDefines: USE_STM32L152D_EVAL; STM32L1XX_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32l1xx_flash_offset.icf
  group Doc
    ../: readme.txt
  group STM32F10x/CMSIS
    ../../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../../src/: system_stm32f10x.c
  group STM32F10x/STM3210B_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group STM32F10x/STM3210C_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_ioe.c
  group STM32F10x/STM3210E_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group STM32L1xx/CMSIS
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
    ../../src/: system_stm32l1xx.c
  group STM32L1xx/STM32L152_EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group STM32L1xx/STM32L152D_EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group STM32L1xx/STM32L1xx_StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group User
    ../src/: main.c stm32_it.c
