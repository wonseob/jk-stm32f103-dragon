# Keil uVision project stm32_high.uvproj, settings and files
target stm32_high (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_high +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\CMSIS\Include;..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../../../src/: main.c usb_pwr.c diskio.c ff.c hw_config.c key.c led.c mmc_sd.c nrf24l01.c queue.c rtc.c spi.c stm32f10x_it.c timer.c usart.c usb_desc.c usb_istr.c usb_prop.c vs1003b.c at24c02.c iic.c rs485.c can.c dac.c adc.c buzzer.c lcd43.c touch.c stm32f10x_conf.h lcd70.c lcd.c icon.c font.c lcd28.c lcd12864.c lcd1602.c lcd32.c
  group CMSIS
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s startup_stm32f10x_cl.s startup_stm32f10x_md.s
  group USB-FS-Device_Driver
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
