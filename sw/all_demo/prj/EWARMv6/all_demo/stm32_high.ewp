# IAR project stm32_high.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\CMSIS\Include; ..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_high.bin
  ILINK.IlinkOutputFile: stm32_high.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_md.s
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Device_Driver
    ../../../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../../../src/: adc.c at24c02.c buzzer.c can.c dac.c diskio.c ff.c font.c hw_config.c icon.c iic.c key.c lcd.c lcd12864.c lcd1602.c lcd28.c lcd32.c lcd43.c lcd70.c led.c main.c mmc_sd.c nrf24l01.c queue.c rs485.c rtc.c spi.c stm32f10x_it.c timer.c touch.c usart.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c vs1003b.c
