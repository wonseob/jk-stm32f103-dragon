# Keil uVision project led.uvproj, settings and files
target stm32f4_dragon (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: led
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\..\..\lib\STM32_USB-Host-Device_Lib_V2.1.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\lib\STM32_USB-Host-Device_Lib_V2.1.0\Libraries\CMSIS\Include;..\..\..\lib\STM32_USB-Host-Device_Lib_V2.1.0\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\lib\STM32_USB-Host-Device_Lib_V2.1.0\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\..\lib\STM32_USB-Host-Device_Lib_V2.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../: stm32f4xx_it.c main.c
  group STM32F4xx_StdPeriph_Driver
    ../../../lib/STM32_USB-Host-Device_Lib_V2.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../../lib/STM32_USB-Host-Device_Lib_V2.1.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MDK-ARM
    ../../../lib/STM32_USB-Host-Device_Lib_V2.1.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
